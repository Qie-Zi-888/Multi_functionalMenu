# Keil uVision project lvgl_demo.uvprojx, settings and files
target lvgl_desktop_demo (ARM-ADS)
  device: -AT32F435VGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.3
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lvgl_desktop_demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: AT32F435VGT7, AT_START_F435_V1, USE_STDPERIPH_DRIVER,AT_SURF_F437_V1,LV_LVGL_H_INCLUDE_SIMPLE
  c misc: --locale=english
  c include: ..\inc;..\..\..\libraries\cmsis\cm4\core_support;..\..\..\libraries\cmsis\cm4\device_support;..\..\..\libraries\at_surf_f437_board;..\..\..\libraries\drivers\inc;..\..\..\middlewares\i2c_application_library;..\..\..\middlewares\3rd_party\fatfs\source;..\porting;..\..\guiprj\custom;..\..\guiprj\generated\guider_customer_fonts;..\..\guiprj\generated\guider_fonts;..\..\guiprj\generated;..\..\guiprj\generated\images;..\..\..\libraries\at32f435_437_board;..\..\..\middlewares\freertos\source\include;..\..\..\middlewares\freertos\source\portable\rvds\ARM_CM4F;..\..\..\middlewares\freertos\source\portable\memmang;..\..\..\libraries\at32_bsp;..\..\..\middlewares\3rd_party\lvgl8310\src;..\..\guiprj\generated\guider_fonts;..\..\guiprj\generated;..\..\guiprj\lvgl\src\widgets;..\..\..\middlewares\3rd_party\lvgl8310\src\core;..\..\..\middlewares\3rd_party\lvgl8310\src\extra\others\ime;..\cJson;..\..\..\middlewares\lvgl-8.3.9
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xb0000000 size 0x1000000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: main.c at32f435_437_clock.c at32f435_437_int.c lv_tick_custom.c include_port.c mywave_oled_api.c page.c algorithms.c check.c chess.c displayChess.c esp12.c font.c
  group bsp
    ../../../libraries/at32_bsp/: bsp.c bsp_esp12.c bsp_key.c bsp_timer.c bsp_uart.c bsp_beep.c bsp_gt911.c bsp_lcd.c bsp_qspi_flash.c
  group firmware
    ../../../libraries/drivers/src/: at32f435_437_crm.c at32f435_437_dma.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_xmc.c at32f435_437_scfg.c at32f435_437_adc.c at32f435_437_spi.c at32f435_437_exint.c at32f435_437_qspi.c
    ../../../middlewares/i2c_application_library/: i2c_application.c
  group cmsis
    ../src/: system_at32f435_437.c
    ./: startup_at32f435_437.s
  group lv_porting
    ../porting/: lv_port_disp_template.c lv_port_indev_template.c
  group lvgl_user
    ../../guiprj/generated/: events_init.c gui_guider.c setup_scr_screen.c widgets_init.c
    ../../guiprj/custom/: custom.c
  group picFont
    ../../guiprj/generated/guider_fonts/: lv_font_montserratMedium_18.c lv_font_SourceHanSerifSC_Regular_18.c
    ../../guiprj/generated/images/: _goodsun_alpha_480x320.c _aichatimg_alpha_48x45.c _back_alpha_50x36.c _bspimg_alpha_48x45.c _chessimg_alpha_48x45.c _wave_alpha_48x45.c _weathimg_alpha_48x45.c _temp_alpha_49x46.c _static_alpha_48x45.c _weathimg_alpha_49x46.c _humidness_alpha_48x45.c
  group freertos
    ../../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../middlewares/freertos/source/portable/memmang/: heap_4.c
  group lvgl_scr
    ../../../middlewares/3rd_party/lvgl8310/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../../middlewares/3rd_party/lvgl8310/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../../middlewares/3rd_party/lvgl8310/src/draw/arm2d/: lv_gpu_arm2d.c
    ../../../middlewares/3rd_party/lvgl8310/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/layouts/flex/: lv_flex.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/layouts/grid/: lv_grid.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/libs/barcode/: code128.c lv_barcode.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/libs/bmp/: lv_bmp.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/libs/freetype/: lv_freetype.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_rawfs.c lv_fs_stdio.c lv_fs_win32.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/libs/png/: lodepng.c lv_png.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/libs/rlottie/: lv_rlottie.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/others/gridnav/: lv_gridnav.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/others/ime/: lv_ime_pinyin.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/others/imgfont/: lv_imgfont.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/others/monkey/: lv_monkey.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/others/msg/: lv_msg.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/others/snapshot/: lv_snapshot.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/themes/basic/: lv_theme_basic.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/themes/default/: lv_theme_default.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/themes/mono/: lv_theme_mono.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/widgets/analogclock/: lv_analogclock.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/widgets/animimg/: lv_animimg.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/widgets/carousel/: lv_carousel.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/widgets/chart/: lv_chart.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/widgets/dclock/: lv_dclock.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/widgets/keyboard/: lv_keyboard.c lv_zh_keyboard.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/widgets/led/: lv_led.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/widgets/list/: lv_list.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/widgets/menu/: lv_menu.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/widgets/meter/: lv_meter.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/widgets/radiobtn/: lv_radiobtn.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/widgets/span/: lv_span.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/widgets/spinner/: lv_spinner.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/widgets/tabview/: lv_tabview.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/widgets/textprogress/: lv_textprogress.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/widgets/tileview/: lv_tileview.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/widgets/video/: lv_video.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/widgets/win/: lv_win.c
    ../../../middlewares/3rd_party/lvgl8310/src/extra/: lv_extra.c
    ../../../middlewares/3rd_party/lvgl8310/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../../../middlewares/3rd_party/lvgl8310/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../../middlewares/3rd_party/lvgl8310/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../../middlewares/3rd_party/lvgl8310/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../../../middlewares/3rd_party/lvgl8310/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../../middlewares/3rd_party/lvgl8310/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../../../middlewares/lvgl-8.3.9/src/extra/widgets/calendar/: lv_calendar.h lv_calendar_header_arrow.h lv_calendar_header_dropdown.h
  group cJson
    ../cJson/: cJSON.c cJSON_Utils.c test.c
